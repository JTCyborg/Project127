; =========================================================================
; FILE: src/app_init.asm
; ПОДМОДУЛЬ ХОЛОДНОЙ АППАРАТНОЙ ИНИЦИАЛИЗАЦИИ И СТАРТОВОГО КАСКАДА ДИСКОВ
; РЕЛИЗ: МОНОЛИТ. Полный автомат перебора B -> C -> D -> Динамический HDD.
; =========================================================================

APP_CORE_Cold_Start_Cascade:
        IF PANEL_MODE_SWITCH == 2
                PUSH    AF
                PUSH    BC
                PUSH    DE
                PUSH    HL

                ; --- ШАГ 1: ПРЕДВАРИТЕЛЬНАЯ ОЧИСТКА ЛЕВОЙ ПАНЕЛИ ПОД TR-DOS ---
                LD      HL, tbl_large_list
                LD      B, 30                   
.clear_left_slots:
                LD      DE, txt_no_files_stub   
                LD      (HL), E : INC HL : LD (HL), D : INC HL
                DJNZ    .clear_left_slots

                ; =========================================================================
                ; ШАГ 2: АВТОМАТИЧЕСКОЕ ТЕСТИРОВАНИЕ ПРИВОДА B
                ; =========================================================================
                LD      A, 1                    ; Логический индекс дисковода B (0=A, 1=B, 2=C, 3=D)
                LD      (23816), A              ; Записываем в системную переменную TR-DOS
                LD      A, "B"
                LD      (nav_right_drive_char), A ; Временно взводим литеру B в шапку панели
                CALL    SELECT_CURRENT_DRIVE    ; Коммутируем порты ВГ93

                LD      HL, tbl_right_list      ; Направляем линковщик в таблицу правой панели
                CALL    LOAD_REAL_DISK_CATALOG  ; Вызываем чтение и парсинг каталога диска Б

                ; --- СИНХРОНИЗАЦИЯ С ЯЧЕЙКOЙ ОШИБОК #5D0F ---
                ; Проверяем системную ячейку ошибок TR-DOS 23823 (#5D0F) из руководства.
                ; Если А = 0 (Ошибки нет, диск Б успешно прочитан) — фиксируем привод и выходим!
                LD      A, (#5D0F)
                AND     A
                JR      Z, .drive_found_exit

                ; =========================================================================
                ; ШАГ 3: АВТОМАТИЧЕСКОЕ ТЕСТИРОВАНИЕ ПРИВОДА C
                ; =========================================================================
                LD      A, 2                    ; Логический индекс дисковода C
                LD      (23816), A
                LD      A, "C"
                LD      (nav_right_drive_char), A
                CALL    SELECT_CURRENT_DRIVE

                LD      HL, tbl_right_list
                CALL    LOAD_REAL_DISK_CATALOG
                
                LD      A, (#5D0F)
                AND     A
                JR      Z, .drive_found_exit

                ; =========================================================================
                ; ШАГ 4: АВТОМАТИЧЕСКОЕ ТЕСТИРОВАНИЕ ПРИВОДА D
                ; =========================================================================
                LD      A, 3                    ; Логический индекс дисковода D
                LD      (23816), A
                LD      A, "D"
                LD      (nav_right_drive_char), A
                CALL    SELECT_CURRENT_DRIVE

                LD      HL, tbl_right_list
                CALL    LOAD_REAL_DISK_CATALOG
                
                LD      A, (#5D0F)
                AND     A
                JR      Z, .drive_found_exit

                ; =========================================================================
                ; ШАГ 5: КАСКАДНЫЙ ПЕРЕХОД НА РЕАЛЬНЫЙ NEMO IDE HDD
                ; =========================================================================
                ; Срабатывает, только если все флоппи-слоты пусты. Никакой статики!
                LD      A, 4                    ; Условный индекс жесткого диска для ядра
                LD      (23816), A
                LD      A, "H"                  ; Фиксируем честную литеру [ H: ] в шапке панели
                LD      (nav_right_drive_char), A

                ; Инициализируем аппаратуру шины Nemo IDE и запускаем динамический рендер FAT16
                CALL    NemoIDE_ResetDrive       ; Аппаратный сброс винчестера
                
                ; Функция из src/fat16_view.asm, которая сама считает сектор LBA 63,
                ; распарсит BPB, найдет Root Directory и выведет файлы на экран панелей
                CALL    NemoIDE_DisplayRootDirectory 
                JR      .restore_left_focus

.drive_found_exit:
                ; Если реальная дискета (B, C или D) была успешно найдена, фиксируем её литеру
                LD      A, (23816)
                ADD     A, 65                   ; Превращаем индекс в ASCII: 1+65='B'..
                LD      (nav_right_drive_char), A

                ; Взводим режим 1 (полная перерисовка текстовых панелей экрана)
                LD      A, 1
                LD      (render_mode_switch), A  
                LD      (render_dirty_flag), A

.restore_left_focus:
                ; Принудительно возвращаем фокус системного канала дисковода на левый диск А
                XOR     A
                LD      (menu_drive_index), A  
                LD      (23816), A
                CALL    SELECT_CURRENT_DRIVE

                POP     HL
                POP     DE
                POP     BC
                POP     AF
        ENDIF
        RET
