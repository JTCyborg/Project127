; =========================================================================
; FILE: src/disk.asm
; ПРОЕКТ 113 — НИЗКОУРОВНЕВАЯ БИБЛИОТЕКА ФУНКЦИЙ TR-DOS (АДАПТИРОВАННАЯ)
; РЕЛИЗ: СВЕРХОТЛАЖЕННЫЙ ФИНАЛЬНЫЙ МОНОЛИТ. Жесткая ОЗУ-синхронизация BANKM #10.
; =========================================================================

; --- ФУНКЦИЯ 1: Выбор и инициализация накопителя ---
TRDOS_SelectDrive:
        PUSH    AF
        PUSH    BC
        LD      (#5D19), A              ; Записываем номер диска в системную переменную DRIVE
        LD      B, 0                    ; Гарантируем чистый B=0 для выбора привода по стандарту ПЗУ
        LD      C, 1                    ; Функция TR-DOS: Инициализация и выбор дисковода
        CALL    TRDOS_ExecuteCommand
        POP     BC
        POP     AF
        RET

; --- ФУНКЦИЯ 2: Блочное чтение произвольных секторов в память ---
; Вход: B = 8 секторов, D = 0 трек, E = 0 сектор, HL = CATALOG_SECTOR_BUF (#C800)
TRDOS_ReadSectors:
        PUSH    BC
        LD      C, 5                    ; Функция TR-DOS: Блочное чтение секторов через ВГ93
        CALL    TRDOS_ExecuteCommand
        POP     BC
        RET

; --- АБСОЛЮТНО СТАБИЛЬНЫЙ СИНХРОННЫЙ ШЛЮЗ В ПЗУ #3D13 ---
TRDOS_ExecuteCommand:
        ; На входе в регистрах лежат параметры TR-DOS: B, C, D, E, H, L
        ; Мгновенно фиксируем их в статические ОЗУ-ячейки, полностью исключая сдвиги стека!
        LD      (tr_save_bc), BC
        LD      (tr_save_de), DE
        LD      (tr_save_hl), HL

        PUSH    AF
        PUSH    IX
        PUSH    IY

        ; Спасаем альтернативную группу регистров Z80 от порчи внутри ПЗУ
        EXX
        PUSH    BC
        PUSH    DE
        PUSH    HL
        EXX
        EX      AF, AF'
        PUSH    AF
        EX      AF, AF'

        ; Включаем страницу ОЗУ 0 (#10) для работы теневого ПЗУ Beta Disc
        PUSH    BC
        LD      A, #10               
        LD      BC, #7FFD
        OUT     (C), A
        POP     BC                      

        ; Очищаем системные регистры команд перед входом в ПЗУ
        XOR     A
        LD      (#5D11), A              ; Сбрасываем внутренний flag команды
        
        ; ЖЕСТКИЙ БАРЬЕР ЗАЩИТЫ ПО КНИГЕ ЛOГАНА: Насильно привязываем IY к ячейке #5C3A (ERR_NR)
        LD      IY, #5C3A

        ; Защита стека SP от проваливания в область системного ПЗУ #3321
        LD      (tr_saved_sp_gate), SP
        LD      SP, #FFFF               

        ; Извлекаем параметры TR-DOS напрямую из чистых статических ячеек памяти
        LD      BC, (tr_save_bc)
        LD      DE, (tr_save_de)
        LD      HL, (tr_save_hl)

        ; Полная блокировка прерываний во избежание заклинивания на векторе #0038
        DI                              
        CALL    #3D13                   
        DI                              
        
        ; Мгновенно восстанавливаем оригинальный рабочий стек коммандера на место
        LD      SP, (tr_saved_sp_gate)

        ; АППАРАТНЫЙ СБРОС СТАТУСА АКТИВНОСТИ ВГ93
        ; --- НЕ ЗАТИРАЕМ РЕГИСТР ОШИБОК TR-DOS #5D0F (23823) ---
        XOR     A
        LD      (#5D11), A              ; Сбрасываем флаг текущей дисковой команды
        LD      (#5C48), A              ; Сбрасываем флаг занятости потока экрана

        ; --- СИНХРОННЫЙ ВOЗВРAТ В ОЗУ КОММАНДЕРА ---
        ; Применяем жесткую легитимную маску #10. Она включает страницу ОЗУ 0 
        ; коммандера при активном ПЗУ-48, полностью исключая падения в черный экран.
        PUSH    BC
        LD      A, #10                  ; Переключаем архитектуру на ОЗУ ядра коммандера
        LD      BC, #7FFD
        OUT     (C), A
        
        ; --- ХАК СИНХРОНИЗАЦИИ СИСТЕМНЫХ ФЛАГOВ БЕЙСИКА ---
        ; Принудительно вколачиваем маску #10 в ячейку BANKM (#5C3B / 23611).
        ; Теперь при любом кадровом прерывании ПЗУ Спектрума будет видеть 
        ; правильное, актуальное состояние ОЗУ-страниц проекта!
        LD      (#5C3B), A              
        POP     BC

        ; Восстанавливаем альтернативную группу регистров Z80
        EX      AF, AF'
        POP     AF
        EX      AF, AF'
        EXX
        POP     HL
        POP     DE
        POP     BC
        EXX

        // Восстанавливаем контекст коммандера
        POP     IY
        POP     IX
        POP     AF
        RET                             ; Чистый и стабильный возврат в менеджер панелей!

; --- ВЫДЕЛЕННЫЕ СТАТИЧЕСКИЕ ЯЧЕЙКИ ХРАНЕНИЯ ПАРАМЕТРОВ ---
        ALIGN 2
tr_save_bc:        DW 0
tr_save_de:        DW 0
tr_save_hl:        DW 0
tr_saved_sp_gate:  DW 0
